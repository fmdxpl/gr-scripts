<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fmdx_sdr</value></param>
<param><key>author</key><value>Konrad Kosmatka</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>FMDX-SDR</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>avg</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>boost</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0.2</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>bw</value></param>
<param><key>block_id</key><value>blocks_probe_signal_x_0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>5</value></param>
<param><key>poll_rate</key><value>samp_rate/bw_rate</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>bw</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>130</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>200</value></param>
<param><key>min</key><value>5</value></param>
<param><key>num_steps</key><value>(150-5)/5</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>bw_rate</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>500</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>5000</value></param>
<param><key>min</key><value>20</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deemphasis</value></param>
<param><key>value</key><value>50e-6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>div</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>firs</value></param>
<param><key>value</key><value>[(-3.704502676837862e-11, 3.4387377922939777e-07, 5.105820832795871e-07, -9.221691357197415e-07, -5.415687155618798e-06, -1.4295345863502007e-05, -2.856413811969105e-05, -4.8714977310737595e-05, -7.455392915289849e-05, -0.0001050499631674029, -0.0001382268383167684, -0.0001711129443719983, -0.00019976684416178614, -0.0002193929540226236, -0.00022455606085713953, -0.00020950120233464986, -0.0001685741444816813, -9.673356544226408e-05, 9.869346285995562e-06, 0.0001532743190182373, 0.0003330994222778827, 0.0005459822714328766, 0.0007851291447877884, 0.001040028058923781, 0.0012963810004293919, 0.0015363022685050964, 0.0017388175474479795, 0.0018806856824085116, 0.0019375422270968556, 0.0018853343790397048, 0.001702011446468532, 0.0013693859800696373, 0.0008750744163990021, 0.00021440447017084807, -0.0006078419974073768, -0.0015759841771796346, -0.0026624230667948723, -0.0038271727971732616, -0.005018035881221294, -0.006171496585011482, -0.00721436133608222, -0.008066132664680481, -0.008642069064080715, -0.008856822736561298, -0.008628497831523418, -0.007882974110543728, -0.00655824039131403, -0.004608549643307924, -0.0020081112161278725, 0.0012458692071959376, 0.005131041165441275, 0.009598804637789726, 0.0145743852481246, 0.019958144053816795, 0.025628138333559036, 0.03144384175539017, 0.03725092113018036, 0.04288685321807861, 0.048187121748924255, 0.05299176275730133, 0.05715188756585121, 0.06053588166832924, 0.06303498893976212, 0.06456796824932098, 0.06508462876081467, 0.06456796824932098, 0.06303498893976212, 0.06053588166832924, 0.05715188756585121, 0.05299175903201103, 0.048187121748924255, 0.042886849492788315, 0.03725092485547066, 0.03144384175539017, 0.025628138333559036, 0.019958144053816795, 0.01457438338547945, 0.009598804637789726, 0.005131041165441275, 0.0012458693236112595, -0.0020081112161278725, -0.004608549177646637, -0.006558240856975317, -0.007882972247898579, -0.008628500625491142, -0.008856823667883873, -0.008642069064080715, -0.008066130802035332, -0.007214363198727369, -0.006171497516334057, -0.00501803494989872, -0.0038271737284958363, -0.0026624230667948723, -0.0015759840607643127, -0.000607841822784394, 0.0002144045429304242, 0.0008750742417760193, 0.0013693857472389936, 0.001702012144960463, 0.0018853346118703485, 0.001937541994266212, 0.0018806849839165807, 0.0017388176638633013, 0.0015363018028438091, 0.0012963805347681046, 0.0010400285245850682, 0.0007851293194107711, 0.0005459822714328766, 0.00033309959690086544, 0.00015327433357015252, 9.869343557511456e-06, -9.673352906247601e-05, -0.00016857423179317266, -0.00020950120233464986, -0.00022455600264947861, -0.0002193931140936911, -0.00019976680050604045, -0.00017111281340476125, -0.0001382268383167684, -0.00010505005047889426, -7.455379818566144e-05, -4.871489363722503e-05, -2.8564190870383754e-05, -1.429532676411327e-05, -5.415663963503903e-06, -9.221586765306711e-07, 5.105820832795871e-07, 3.4387377922939777e-07, -3.704502676837862e-11), (-4.539076066357756e-26, 2.6650624818103097e-07, 2.107085492752958e-06, 6.894400030432735e-06, 1.5520387023570947e-05, 2.813797618728131e-05, 4.3961917981505394e-05, 6.115695578046143e-05, 7.683901640120894e-05, 8.721077028894797e-05, 8.784177771303803e-05, 7.409173849737272e-05, 4.166329381405376e-05, -1.2748626431857701e-05, -9.076104470295832e-05, -0.00019162552780471742, -0.0003116470470558852, -0.00044378559687174857, -0.0005775248864665627, -0.0006990814581513405, -0.0007920136558823287, -0.0008382497471757233, -0.000819527602288872, -0.0007191823679022491, -0.0005241807666607201, -0.00022724908194504678, 0.0001710951910354197, 0.0006608212715946138, 0.0012212006840854883, 0.0018203698564320803, 0.002415826078504324, 0.0029559768736362457, 0.0033827933948487043, 0.0036355238407850266, 0.0036553326062858105, 0.0033905969467014074, 0.0028025477658957243, 0.0018708237912505865, 0.0005984791205264628, -0.0009840360144153237, -0.002816373948007822, -0.004807659424841404, -0.006838012952357531, -0.008762380108237267, -0.010416628792881966, -0.011625751852989197, -0.012213747948408127, -0.012014705687761307, -0.010884331539273262, -0.008711249567568302, -0.005427174270153046, -0.0010152339236810803, 0.004484293982386589, 0.010971395298838615, 0.018287256360054016, 0.026218866929411888, 0.03450721874833107, 0.04285866767168045, 0.05095897987484932, 0.05848914384841919, 0.06514208763837814, 0.0706392154097557, 0.07474573701620102, 0.07728376239538193, 0.07814232259988785, 0.07728376239538193, 0.07474573701620102, 0.0706392154097557, 0.06514208763837814, 0.05848914012312889, 0.05095897987484932, 0.04285866767168045, 0.03450721874833107, 0.026218866929411888, 0.018287256360054016, 0.010971395298838615, 0.004484293516725302, -0.0010152339236810803, -0.005427174735814333, -0.008711249567568302, -0.010884331539273262, -0.012014703825116158, -0.012213748879730701, -0.011625749990344048, -0.01041663158684969, -0.008762381039559841, -0.006838012952357531, -0.004807658493518829, -0.002816374646499753, -0.0009840361308306456, 0.000598479004111141, 0.0018708243733271956, 0.0028025477658957243, 0.0033905967138707638, 0.003655331674963236, 0.003635525004938245, 0.0033827926963567734, 0.0029559764079749584, 0.0024158270098268986, 0.001820370089262724, 0.0012212004512548447, 0.0006608210387639701, 0.0001710951910354197, -0.00022724900918547064, -0.0005241805920377374, -0.0007191827171482146, -0.0008195277769118547, -0.0008382497471757233, -0.0007920140633359551, -0.0006990815745666623, -0.00057752471184358, -0.0004437854222487658, -0.00031164722167886794, -0.00019162552780471742, -9.076102287508547e-05, -1.2748635526804719e-05, 4.1663286538096145e-05, 7.40916802897118e-05, 8.784177771303803e-05, 8.721084304852411e-05, 7.683887815801427e-05, 6.115685391705483e-05, 4.396200165501796e-05, 2.8137937988503836e-05, 1.552032153995242e-05, 6.894321813888382e-06, 2.107085492752958e-06, 2.6650624818103097e-07, -4.539076066357756e-26), (3.7051660350950755e-11, -7.940984119159111e-07, -3.974664195993682e-06, -1.00815896075801e-05, -1.8569957319414243e-05, -2.7693215088220313e-05, -3.4589542337926105e-05, -3.558779280865565e-05, -2.6724936105892994e-05, -4.438752512214705e-06, 3.3632913982728496e-05, 8.784059173194692e-05, 0.00015581560728605837, 0.00023199549468699843, 0.0003075059794355184, 0.00037050459650345147, 0.000407046900363639, 0.00040248665027320385, 0.0003433409729041159, 0.00021947828645352274, 2.6412586521473713e-05, -0.00023258182045537978, -0.0005448528681881726, -0.0008875761996023357, -0.0012280705850571394, -0.0015254273312166333, -0.001733532059006393, -0.001805401174351573, -0.0016985740512609482, -0.0013811185490339994, -0.0008376656332984567, -7.475886377505958e-05, 0.0008752311114221811, 0.0019523410592228174, 0.0030699954368174076, 0.00411910330876708, 0.0049753692001104355, 0.005509568378329277, 0.005600173957645893, 0.005147386342287064, 0.0040873391553759575, 0.002405056031420827, 0.00014468545850832015, -0.0025843637995421886, -0.005606528837233782, -0.008685185573995113, -0.01153395976871252, -0.013833949342370033, -0.015255850739777088, -0.015485578216612339, -0.014251352287828922, -0.01134999468922615, -0.006670118775218725, -0.00020986240997444838, 0.007912678644061089, 0.017457783222198486, 0.028071846812963486, 0.039304472506046295, 0.05063395947217941, 0.06149950996041298, 0.07133781909942627, 0.07962115854024887, 0.08589410036802292, 0.0898057296872139, 0.09113479405641556, 0.0898057296872139, 0.08589410036802292, 0.07962115854024887, 0.07133781909942627, 0.06149950623512268, 0.05063395947217941, 0.039304468780756, 0.028071848675608635, 0.017457783222198486, 0.007912678644061089, -0.00020986240997444838, -0.006670117843896151, -0.011349995620548725, -0.014251353219151497, -0.015485580079257488, -0.015255850739777088, -0.013833947479724884, -0.011533960700035095, -0.008685183711349964, -0.005606530234217644, -0.0025843640323728323, 0.00014468545850832015, 0.0024050555657595396, 0.004087340086698532, 0.005147386807948351, 0.0056001730263233185, 0.005509569775313139, 0.0049753692001104355, 0.004119102843105793, 0.003069994505494833, 0.0019523416412994266, 0.0008752309367991984, -7.475884922314435e-05, -0.0008376659825444221, -0.001381118781864643, -0.0016985738184303045, -0.001805400475859642, -0.0017335321754217148, -0.001525426865555346, -0.001228070119395852, -0.0008875766070559621, -0.0005448529846034944, -0.00023258182045537978, 2.641260107338894e-05, 0.0002194783155573532, 0.00034334088559262455, 0.0004024864756502211, 0.00040704713319428265, 0.00037050459650345147, 0.00030750592122785747, 0.00023199565475806594, 0.0001558155781822279, 8.784051897237077e-05, 3.3632913982728496e-05, -4.4387561501935124e-06, -2.67248888121685e-05, -3.558773096301593e-05, -3.458960782154463e-05, -2.7693178708432242e-05, -1.856987910286989e-05, -1.0081475011247676e-05, -3.974664195993682e-06, -7.940984119159111e-07, 3.7051660350950755e-11), (-6.418580250633354e-11, 1.0755539960882743e-06, 4.430838089319877e-06, 9.205871720041614e-06, 1.319662533205701e-05, 1.3215384569775779e-05, 5.764908109995304e-06, -1.2059507753292564e-05, -4.157748116995208e-05, -8.161865116562694e-05, -0.00012790267646778375, -0.00017288948583882302, -0.00020624500757548958, -0.0002159912110073492, -0.00019030239491257817, -0.00011979105329373851, 2.698240410681131e-19, 0.00016628162120468915, 0.0003673285827971995, 0.0005818611825816333, 0.0007798736332915723, 0.0009251263691112399, 0.0009792990749701858, 0.0009075258276425302, 0.0006847517797723413, 0.0003020920557901263, -0.0002278007596032694, -0.0008674085256643593, -0.0015540135791525245, -0.0022030414547771215, -0.002715352224186063, -0.0029882094822824, -0.0029290569946169853, -0.002470678649842739, -0.0015858369879424572, -0.0002992312074638903, 0.0013053652364760637, 0.0030846484005451202, 0.004843233153223991, 0.006349365692585707, 0.007358213886618614, 0.007640931289643049, 0.007016701158136129, 0.005384179297834635, 0.002748345024883747, -0.0007611403707414865, -0.004883436020463705, -0.009234177879989147, -0.013328127562999725, -0.016615988686680794, -0.018532754853367805, -0.018553387373685837, -0.01625044085085392, -0.011347427032887936, -0.0037619182839989662, 0.006367128808051348, 0.018671806901693344, 0.03256956487894058, 0.04729923605918884, 0.06197627633810043, 0.0756625235080719, 0.08744397014379501, 0.09650921076536179, 0.1022205799818039, 0.10417100042104721, 0.1022205799818039, 0.09650921076536179, 0.08744397014379501, 0.0756625235080719, 0.061976272612810135, 0.04729923605918884, 0.032569561153650284, 0.018671808764338493, 0.006367128808051348, -0.0037619182839989662, -0.011347427032887936, -0.01625043898820877, -0.018553389236330986, -0.018532756716012955, -0.016615990549325943, -0.013328127562999725, -0.009234176017343998, -0.004883436486124992, -0.0007611402543261647, 0.002748345723375678, 0.005384179763495922, 0.007016701158136129, 0.007640929892659187, 0.007358215283602476, 0.006349366623908281, 0.004843232221901417, 0.003084649331867695, 0.0013053652364760637, -0.00029923117836005986, -0.001585836405865848, -0.00247067934833467, -0.002929056528955698, -0.002988208783790469, -0.0027153531555086374, -0.002203041687607765, -0.0015540133463218808, -0.0008674082346260548, -0.00022780077415518463, 0.00030209196847863495, 0.0006847515469416976, 0.0009075262350961566, 0.0009792993078008294, 0.0009251263691112399, 0.0007798740989528596, 0.0005818612989969552, 0.0003673284954857081, 0.00016628156299702823, 2.698241703150838e-19, -0.00011979105329373851, -0.00019030235125683248, -0.0002159913710784167, -0.0002062449639197439, -0.00017288934031967074, -0.00012790267646778375, -8.161870937328786e-05, -4.157740477239713e-05, -1.2059487744409125e-05, 5.764918569184374e-06, 1.3215367289376445e-05, 1.3196569852880202e-05, 9.20576712815091e-06, 4.430838089319877e-06, 1.0755539960882743e-06, -6.418580250633354e-11), (7.411297270332184e-11, -1.0231103715341305e-06, -3.311256023152964e-06, -4.614846147887874e-06, -1.829219513638236e-06, 7.968996214913204e-06, 2.6309204258723184e-05, 5.222292384132743e-05, 8.155451359925792e-05, 0.0001069568534148857, 0.00011874083429574966, 0.00010659183317329735, 6.19797283434309e-05, -1.9109274944639765e-05, -0.00013365187624003738, -0.0002698968455661088, -0.0004070998984389007, -0.0005171304219402373, -0.0005681121838279068, -0.000529876328073442, -0.0003805861051660031, -0.00011348464613547549, 0.00025754712987691164, 0.0006950201350264251, 0.0011386636178940535, 0.001510799047537148, 0.0017263037152588367, 0.0017063432605937123, 0.0013941653305664659, 0.0007704899180680513, -0.00013438133464660496, -0.0012346295407041907, -0.0023914873600006104, -0.0034255851060152054, -0.004138865042477846, -0.00434412294998765, -0.003898585680872202, -0.0027365905698388815, -0.0008957255049608648, 0.001469072187319398, 0.00408787140622735, 0.006597008556127548, 0.008579024113714695, 0.009618071839213371, 0.009364631958305836, 0.007601166609674692, 0.004298923071473837, -0.0003436902188695967, -0.005889305379241705, -0.011681482195854187, -0.016897426918148994, -0.020630035549402237, -0.021991297602653503, -0.0202252808958292, -0.01481656450778246, -0.005579472053796053, 0.0072851404547691345, 0.023175247013568878, 0.04111993685364723, 0.05985746905207634, 0.07795188575983047, 0.0939355343580246, 0.10646127164363861, 0.11444606631994247, 0.11718856543302536, 0.11444606631994247, 0.10646127164363861, 0.0939355343580246, 0.07795188575983047, 0.05985746532678604, 0.04111993685364723, 0.02317524515092373, 0.007285140920430422, -0.005579472053796053, -0.01481656450778246, -0.0202252808958292, -0.021991293877363205, -0.020630037412047386, -0.016897428780794144, -0.011681483127176762, -0.005889305379241705, -0.0003436901606619358, 0.004298923537135124, 0.00760116521269083, 0.009364633820950985, 0.009618072770535946, 0.008579024113714695, 0.006597007159143686, 0.004087872337549925, 0.0014690724201500416, -0.000895725330337882, -0.0027365912683308125, -0.003898585680872202, -0.00434412294998765, -0.0041388641111552715, -0.0034255862701684237, -0.002391486894339323, -0.001234629307873547, -0.00013438139285426587, 0.0007704899762757123, 0.0013941650977358222, 0.0017063426785171032, 0.0017263038316741586, 0.0015107985818758607, 0.001138663268648088, 0.0006950204260647297, 0.00025754718808457255, -0.00011348464613547549, -0.0003805863088928163, -0.0005298764444887638, -0.0005681120092049241, -0.0005171302473172545, -0.00040710013126954436, -0.0002698968455661088, -0.00013365184713620692, -1.9109289496554993e-05, 6.197971379151568e-05, 0.00010659175313776359, 0.00011874083429574966, 0.00010695694072637707, 8.155436808010563e-05, 5.222283652983606e-05, 2.630925337143708e-05, 7.968985300976783e-06, -1.8292116692464333e-06, -4.6147933971951716e-06, -3.311256023152964e-06, -1.0231103715341305e-06, 7.411297270332184e-11), (-6.4180931402813e-11, 6.53209326628712e-07, 1.0147430202778196e-06, -1.8373632428847486e-06, -1.0367734830651898e-05, -2.5110306523856707e-05, -4.357344369054772e-05, -5.9957925259368494e-05, -6.596625462407246e-05, -5.272977068671025e-05, -1.3568545909947716e-05, 5.299686745274812e-05, 0.00014077317609917372, 0.00023481182870455086, 0.0003124147478956729, 0.00034656375646591187, 0.00031156724435277283, 0.00019010268442798406, -1.9741299183806404e-05, -0.00029917966458015144, -0.0006069777882657945, -0.0008826011326164007, -0.0010548013960942626, -0.001055011060088873, -0.0008336376631632447, -0.00037621959927491844, 0.000284271634882316, 0.001062667230144143, 0.0018271878361701965, 0.002416495466604829, 0.002667034976184368, 0.002446987899020314, 0.0016909635160118341, 0.00042821976239793, -0.0012028459459543228, -0.002959717297926545, -0.004523073323071003, -0.005545110907405615, -0.005713048856705427, -0.004817875102162361, -0.0028156526386737823, 0.00013201541150920093, 0.003649851307272911, 0.0071802097372710705, 0.010054487735033035, 0.011597868986427784, 0.011253371834754944, 0.00870573241263628, 0.003982921596616507, -0.0024856477975845337, -0.009870249778032303, -0.017008770257234573, -0.02253829501569271, -0.025076009333133698, -0.023425418883562088, -0.016777407377958298, -0.004873949568718672, 0.01189422607421875, 0.032476138323545456, 0.05524298548698425, 0.0781579539179802, 0.09901275485754013, 0.11569926887750626, 0.126477912068367, 0.13020385801792145, 0.126477912068367, 0.11569926887750626, 0.09901275485754013, 0.0781579539179802, 0.055242981761693954, 0.032476138323545456, 0.011894225142896175, -0.004873949568718672, -0.016777407377958298, -0.023425418883562088, -0.025076009333133698, -0.022538291290402412, -0.017008772119879723, -0.009870249778032303, -0.0024856480304151773, 0.003982921596616507, 0.00870573054999113, 0.011253372766077518, 0.011597867123782635, 0.010054490529000759, 0.007180210202932358, 0.003649851307272911, 0.00013201538240537047, -0.0028156533371657133, -0.0048178755678236485, -0.005713047459721565, -0.005545112304389477, -0.004523073323071003, -0.0029597170650959015, -0.0012028455967083573, 0.0004282199079170823, 0.0016909631667658687, 0.002446987433359027, 0.0026670359075069427, 0.0024164956994354725, 0.0018271876033395529, 0.0010626667644828558, 0.00028427166398614645, -0.0003762194828595966, -0.0008336373721249402, -0.0010550115257501602, -0.0010548016289249063, -0.0008826011326164007, -0.0006069780793040991, -0.00029917972278781235, -1.9741293726838194e-05, 0.00019010261166840792, 0.00031156741897575557, 0.00034656375646591187, 0.000312414689688012, 0.00023481198877561837, 0.00014077314699534327, 5.2996823797002435e-05, -1.3568545909947716e-05, -5.272981434245594e-05, -6.596613820875064e-05, -5.9957823395961896e-05, -4.357352736406028e-05, -2.511027196305804e-05, -1.0367690265411511e-05, -1.8373424381934456e-06, 1.0147430202778196e-06, 6.53209326628712e-07, -6.4180931402813e-11), (3.7057645146942875e-11, -8.067266321631905e-08, 1.6424529576397617e-06, 7.5487696449272335e-06, 1.7859209037851542e-05, 2.9519249437726103e-05, 3.6316811019787565e-05, 3.0468461773125455e-05, 5.43858823220944e-06, -4.072159936185926e-05, -0.00010257778194500133, -0.0001662056311033666, -0.00021066836779937148, -0.00021238408226054162, -0.00015185229131020606, -2.1330641175154597e-05, 0.00016863158089108765, 0.00038612514617852867, 0.0005802087252959609, 0.000689494947437197, 0.0006562791531905532, 0.00044371135300025344, 5.2010964282089844e-05, -0.00047103449469432235, -0.0010296461405232549, -0.0014923791168257594, -0.0017170546343550086, -0.0015847391914576292, -0.001035990659147501, -0.00010045205272035673, 0.001089345314539969, 0.0023070245515555143, 0.0032669345382601023, 0.0036810189485549927, 0.003328480990603566, 0.0021236406173557043, 0.00016501994105055928, -0.0022499863989651203, -0.004655041266232729, -0.006490709260106087, -0.00721681909635663, -0.006441660225391388, -0.0040410165674984455, -0.0002378353092353791, 0.004382443614304066, 0.008935332298278809, 0.012378586456179619, 0.013713127933442593, 0.012209690175950527, 0.007617088034749031, 0.00030584412161260843, -0.008691429160535336, -0.017764989286661148, -0.024937406182289124, -0.028171570971608162, -0.025729093700647354, -0.016516638919711113, -0.00035440505598671734, 0.02188922092318535, 0.048331793397665024, 0.07628525793552399, 0.10261248797178268, 0.12417720258235931, 0.1383134424686432, 0.1432349532842636, 0.1383134424686432, 0.12417720258235931, 0.10261248797178268, 0.07628525793552399, 0.048331789672374725, 0.02188922092318535, -0.00035440505598671734, -0.016516638919711113, -0.025729093700647354, -0.028171570971608162, -0.024937406182289124, -0.017764987424016, -0.008691429160535336, 0.0003058441507164389, 0.007617088500410318, 0.012209690175950527, 0.013713126070797443, 0.012378587387502193, 0.008935331366956234, 0.004382445011287928, -0.00023783532378729433, -0.0040410165674984455, -0.006441658828407526, -0.0072168209590017796, -0.006490710191428661, -0.004655040334910154, -0.0022499870974570513, 0.00016501994105055928, 0.0021236403845250607, 0.0033284800592809916, 0.0036810203455388546, 0.003266934072598815, 0.0023070243187248707, 0.0010893457802012563, -0.00010045206727227196, -0.0010359905427321792, -0.00158473860938102, -0.0017170547507703304, -0.001492378651164472, -0.0010296456748619676, -0.00047103469842113554, 5.2010975196026266e-05, 0.00044371135300025344, 0.0006562795024365187, 0.0006894950638525188, 0.0005802085506729782, 0.0003861249715555459, 0.00016863166820257902, -2.1330641175154597e-05, -0.0001518522622063756, -0.0002123842277796939, -0.0002106683241436258, -0.00016620550013612956, -0.00010257778194500133, -4.072162846568972e-05, 5.438578682515072e-06, 3.0468410841422155e-05, 3.631687650340609e-05, 2.9519209419959225e-05, 1.7859132640296593e-05, 7.548684152425267e-06, 1.6424529576397617e-06, -8.067266321631905e-08, 3.7057645146942875e-11), (9.075826841937857e-26, -5.169062546883652e-07, -3.7156146390771028e-06, -1.0214209396508522e-05, -1.724091089272406e-05, -1.8953940525534563e-05, -8.615835213277023e-06, 1.7942582417163067e-05, 5.879496893612668e-05, 0.00010387616930529475, 0.0001357704313704744, 0.00013392195978667587, 8.170455839717761e-05, -2.5460016331635416e-05, -0.00017366130487062037, -0.0003286411811131984, -0.00044062259257771075, -0.00045618589501827955, -0.000335207354510203, -6.858703272882849e-05, 0.0003089492383878678, 0.0007166123250499368, 0.0010395392309874296, 0.0011550093768164515, 0.0009683116222731769, 0.00044946372509002686, -0.0003404553863219917, -0.0012440660502761602, -0.0020302620250731707, -0.002444345038384199, -0.0022770415525883436, -0.0014361196663230658, 2.0708328082512445e-18, 0.0017662679310888052, 0.00344534101895988, 0.0045528048649430275, 0.004659272730350494, 0.003522023558616638, 0.0011908893939107656, -0.001946271862834692, -0.005202647298574448, -0.007721117697656155, -0.008673756383359432, -0.007490880787372589, -0.004063325468450785, 0.0011406048433855176, 0.007089111488312483, 0.012350421398878098, 0.01538882590830326, 0.014939947053790092, 0.010384303517639637, 0.0020275027491152287, -0.008794005028903484, -0.019830966368317604, -0.02826523594558239, -0.03122912161052227, -0.026403915137052536, -0.012574123218655586, 0.009987147524952888, 0.03939870372414589, 0.0723634660243988, 0.10465359687805176, 0.13180594146251678, 0.14989690482616425, 0.15624462068080902, 0.14989690482616425, 0.13180594146251678, 0.10465359687805176, 0.0723634660243988, 0.03939869999885559, 0.009987147524952888, -0.012574122287333012, -0.026403916999697685, -0.03122912161052227, -0.02826523594558239, -0.019830966368317604, -0.00879400409758091, 0.0020275027491152287, 0.010384304448962212, 0.014939947985112667, 0.01538882590830326, 0.012350419536232948, 0.00708911195397377, 0.0011406047269701958, -0.004063326865434647, -0.007490881718695164, -0.008673756383359432, -0.007721116300672293, -0.0052026486955583096, -0.0019462720956653357, 0.001190889161080122, 0.003522024489939213, 0.004659272730350494, 0.00455280439928174, 0.0034453398548066616, 0.0017662685131654143, 2.0708323946609382e-18, -0.001436119433492422, -0.0022770424839109182, -0.002444345271214843, -0.002030261792242527, -0.001244065584614873, -0.00034045541542582214, 0.00044946360867470503, 0.0009683112730272114, 0.0011550099588930607, 0.0010395394638180733, 0.0007166123250499368, 0.0003089493839070201, -6.85870400047861e-05, -0.00033520726719871163, -0.0004561857203952968, -0.0004406228254083544, -0.0003286411811131984, -0.00017366126121487468, -2.546003452152945e-05, 8.170454384526238e-05, 0.00013392185792326927, 0.0001357704313704744, 0.00010387624934082851, 5.8794863434741274e-05, 1.7942551494343206e-05, -8.615851584181655e-06, -1.8953915059682913e-05, -1.7240838133147918e-05, -1.0214092981186695e-05, -3.7156146390771028e-06, -5.169062546883652e-07, 9.075826841937857e-26), (-3.70569790131281e-11, 9.54141114561935e-07, 4.4683874875772744e-06, 8.76044578035362e-06, 8.797435839369427e-06, -1.221893057845591e-06, -2.3933091142680496e-05, -5.521359707927331e-05, -8.297532622236758e-05, -8.976498065749183e-05, -5.9189958847127855e-05, 1.5570982213830575e-05, 0.00012436856923159212, 0.00023748008243273944, 0.00031055163708515465, 0.00029749993700534105, 0.00016862855409272015, -7.171389006543905e-05, -0.00037510477704927325, -0.000652894435916096, -0.0007965854019857943, -0.000711817410774529, -0.00035709154326468706, 0.00022579063079319894, 0.0009029591456055641, 0.001470290357246995, 0.0017058822559192777, 0.0014422886306419969, 0.000637948396615684, -0.0005773219163529575, -0.0019046298693865538, -0.002936330158263445, -0.0032668758649379015, -0.002627830719575286, -0.0010068884585052729, 0.0012922175228595734, 0.003681030822917819, 0.005417209584265947, 0.005812004674226046, 0.004462061915546656, 0.0014354888116940856, -0.002656120341271162, -0.006743934471160173, -0.009548405185341835, -0.009937996976077557, -0.007308878004550934, -0.0018723966786637902, 0.005253368988633156, 0.012209471315145493, 0.01681378483772278, 0.017150094732642174, 0.0121865039691329, 0.0022525466047227383, -0.010779100470244884, -0.02369828335940838, -0.03254776820540428, -0.0334918275475502, -0.023771263659000397, -0.002512036357074976, 0.028828443959355354, 0.06651809811592102, 0.1051342785358429, 0.1385701298713684, 0.1612491011619568, 0.16927462816238403, 0.1612491011619568, 0.1385701298713684, 0.1051342785358429, 0.06651809811592102, 0.028828442096710205, -0.002512036357074976, -0.023771261796355247, -0.0334918275475502, -0.03254776820540428, -0.02369828335940838, -0.010779100470244884, 0.0022525463718920946, 0.012186504900455475, 0.017150096595287323, 0.016813786700367928, 0.012209471315145493, 0.005253368057310581, -0.001872396795079112, -0.007308876607567072, -0.00993799977004528, -0.00954840611666441, -0.006743934471160173, -0.002656119642779231, 0.0014354890445247293, 0.004462062381207943, 0.005812003742903471, 0.005417210981249809, 0.003681030822917819, 0.0012922174064442515, -0.0010068881092593074, -0.0026278316508978605, -0.003266875399276614, -0.0029363296926021576, -0.0019046305678784847, -0.0005773219745606184, 0.0006379483384080231, 0.0014422881649807096, 0.0017058823723345995, 0.0014702898915857077, 0.0009029588545672596, 0.00022579074720852077, -0.00035709163057617843, -0.000711817410774529, -0.0007965858094394207, -0.0006528944941237569, -0.0003751046606339514, -7.171386096160859e-05, 0.00016862864140421152, 0.00029749993700534105, 0.00031055157887749374, 0.00023748025705572218, 0.00012436854012776166, 1.5570971299894154e-05, -5.9189958847127855e-05, -8.976505341706797e-05, -8.29751807032153e-05, -5.5213506129803136e-05, -2.393313479842618e-05, -1.2218913525430253e-06, 8.797398550086655e-06, 8.760346645431127e-06, 4.4683874875772744e-06, 9.54141114561935e-07, -3.70569790131281e-11), (6.41825273484109e-11, -1.0952484217341407e-06, -3.6324843222246272e-06, -3.77214223590272e-06, 3.6407548122951994e-06, 2.0778446923941374e-05, 4.301071021473035e-05, 5.8198569604428485e-05, 5.06189426232595e-05, 8.871069439919665e-06, -6.525723438244313e-05, -0.00015143754717428237, -0.00021305248083081096, -0.00020863887039013207, -0.00011010980233550072, 7.867105887271464e-05, 0.0003115749859716743, 0.0005056182271800935, 0.0005646997014991939, 0.00041684816824272275, 5.2802784921368584e-05, -0.00045033375499770045, -0.0009347760933451355, -0.0012029744684696198, -0.001086444710381329, -0.0005216380814090371, 0.00039628444937989116, 0.0014091972261667252, 0.002155368449166417, 0.0022843393962830305, 0.0015951982932165265, 0.0001494893804192543, -0.0016910055419430137, -0.00333299464546144, -0.004123826045542955, -0.00358349597081542, -0.001621111179701984, 0.0013490105047821999, 0.0044554187916219234, 0.006596557330340147, 0.006797755602747202, 0.004591925535351038, 0.00028936448507010937, -0.004982052370905876, -0.00952321570366621, -0.011560832150280476, -0.009863908402621746, -0.004283971153199673, 0.003983020316809416, 0.012552193365991116, 0.018442057073116302, 0.018979016691446304, 0.01276723574846983, 0.00041975764906965196, -0.015218758024275303, -0.029501833021640778, -0.037022240459918976, -0.03303085267543793, -0.014860748313367367, 0.017053622752428055, 0.058889806270599365, 0.10402436554431915, 0.14439523220062256, 0.1723174899816513, 0.18228992819786072, 0.1723174899816513, 0.14439523220062256, 0.10402436554431915, 0.058889806270599365, 0.017053622752428055, -0.014860748313367367, -0.03303084895014763, -0.037022244185209274, -0.029501833021640778, -0.015218758024275303, 0.00041975764906965196, 0.01276723388582468, 0.018979016691446304, 0.01844205893576145, 0.01255219429731369, 0.003983020316809416, -0.004283970687538385, -0.00986390933394432, -0.011560830287635326, -0.00952321756631136, -0.0049820528365671635, 0.00028936448507010937, 0.004591924604028463, 0.006797757465392351, 0.006596557796001434, 0.004455417860299349, 0.0013490108540281653, -0.001621111179701984, -0.0035834957379847765, -0.0041238246485590935, -0.0033329958096146584, -0.0016910051926970482, 0.00014948935131542385, 0.0015951989917084575, 0.002284339629113674, 0.0021553682163357735, 0.001409196644090116, 0.0003962844784837216, -0.0005216379067860544, -0.0010864443611353636, -0.0012029750505462289, -0.0009347762679681182, -0.00045033375499770045, 5.2802810387220234e-05, 0.00041684822645038366, 0.0005646995850838721, 0.0005056180525571108, 0.00031157516059465706, 7.867105887271464e-05, -0.00011010977323167026, -0.00020863903046119958, -0.00021305243717506528, -0.00015143743075896055, -6.525723438244313e-05, 8.87107671587728e-06, 5.061885531176813e-05, 5.8198471379000694e-05, 4.301079025026411e-05, 2.0778417820110917e-05, 3.6407393508852692e-06, -3.7720992622780614e-06, -3.6324843222246272e-06, -1.0952484217341407e-06, 6.41825273484109e-11), (-7.411219554720461e-11, 8.965456572695985e-07, 1.5055202311486937e-06, -2.7375319859856972e-06, -1.4425955669139512e-05, -2.9797301976941526e-05, -3.788139292737469e-05, -2.504891381249763e-05, 1.62220312631689e-05, 7.86198434070684e-05, 0.0001369365636492148, 0.0001547537831356749, 0.0001006485617836006, -3.179730265401304e-05, -0.00020992424106225371, -0.0003635999164544046, -0.000407095649279654, -0.0002767440164461732, 2.9606319003505632e-05, 0.00043051960528828204, 0.0007725856848992407, 0.0008802805677987635, 0.0006314055644907057, 2.962178950838279e-05, -0.0007608227315358818, -0.0014446518616750836, -0.0016928737750276923, -0.0012809355976060033, -0.0002154036919819191, 0.0012106827925890684, 0.002475723857060075, 0.0030017674434930086, 0.0023914622142910957, 0.0006405951571650803, -0.0017717084847390652, -0.003980635199695826, -0.005019042175263166, -0.004204009659588337, -0.0014832722954452038, 0.002413068199530244, 0.0061178687028586864, 0.008066384121775627, 0.007103549782186747, 0.003039842937141657, -0.003082339419052005, -0.009174125269055367, -0.012745114974677563, -0.011831716634333134, -0.005889243446290493, 0.003711747471243143, 0.013849761337041855, 0.020530300214886665, 0.02026708424091339, 0.011534801684319973, -0.004228763282299042, -0.02250344678759575, -0.0366244912147522, -0.03960169851779938, -0.02631903812289238, 0.004568844102323055, 0.049690909683704376, 0.10135401785373688, 0.14926005899906158, 0.18310420215129852, 0.1953122317790985, 0.18310420215129852, 0.14926005899906158, 0.10135401785373688, 0.049690909683704376, 0.004568843636661768, -0.02631903812289238, -0.03960169479250908, -0.036624494940042496, -0.02250344678759575, -0.004228763282299042, 0.011534801684319973, 0.020267082378268242, 0.020530300214886665, 0.01384976226836443, 0.0037117477040737867, -0.005889243446290493, -0.011831714771687984, -0.012745115906000137, -0.009174123406410217, -0.0030823403503745794, 0.0030398431699723005, 0.007103549782186747, 0.008066382259130478, 0.006117869634181261, 0.0024130684323608875, -0.0014832720626145601, -0.0042040105909109116, -0.005019042175263166, -0.003980634734034538, -0.0017717080190777779, 0.000640595331788063, 0.0023914617486298084, 0.0030017667450010777, 0.002475725021213293, 0.0012106829090043902, -0.00021540366287808865, -0.001280935131944716, -0.0016928738914430141, -0.0014446513960137963, -0.0007608224987052381, 2.9621804060298018e-05, 0.0006314057391136885, 0.0008802805677987635, 0.0007725860923528671, 0.00043051966349594295, 2.9606309908558615e-05, -0.00027674390003085136, -0.0004070958821102977, -0.0003635999164544046, -0.00020992419740650803, -3.179732448188588e-05, 0.00010064853995572776, 0.00015475366672035307, 0.0001369365636492148, 7.861990889068693e-05, 1.6222002159338444e-05, -2.504887197574135e-05, -3.7881462048972026e-05, -2.9797261959174648e-05, -1.4425893823499791e-05, -2.7375008357921615e-06, 1.5055202311486937e-06, 8.965456572695985e-07, -7.411219554720461e-11), (6.418367226590505e-11, -4.19646397631368e-07, 1.1566422699615941e-06, 8.143034392560367e-06, 1.8662225556909107e-05, 2.3704245904809795e-05, 1.1430796803324483e-05, -2.3654787582927383e-05, -7.2011913289316e-05, -0.00010762624879134819, -9.788921306608245e-05, -2.261427289340645e-05, 0.00010675671364879236, 0.00023998857068363577, 0.0003019440337084234, 0.00022685996373184025, -5.396301426566915e-19, -0.0003149036783725023, -0.000582823297008872, -0.0006465079495683312, -0.00040367888868786395, 0.00012100829917471856, 0.0007494980818592012, 0.0011967067839577794, 0.0011859855148941278, 0.0005925551522523165, -0.00045168877113610506, -0.001555858412757516, -0.0021976339630782604, -0.0019486958626657724, -0.0007088255370035768, 0.0011659025913104415, 0.002928959671407938, 0.003714985679835081, 0.0029301471076905727, 0.0005971611826680601, -0.0025216881185770035, -0.005129411816596985, -0.005896550603210926, -0.004081737715750933, 4.5054563411808604e-18, 0.004912030417472124, 0.008542709052562714, 0.008953265845775604, 0.0053092180751264095, -0.0015189709374681115, -0.009023113176226616, -0.013884782791137695, -0.013327684253454208, -0.006483021657913923, 0.0048378584906458855, 0.01641136221587658, 0.02298082783818245, 0.020353717729449272, 0.007459220942109823, -0.012489157728850842, -0.032339442521333694, -0.042947784066200256, -0.03620006516575813, -0.008106615394353867, 0.03916449844837189, 0.09715929627418518, 0.15312670171260834, 0.19358505308628082, 0.2083350569009781, 0.19358505308628082, 0.15312670171260834, 0.09715929627418518, 0.03916449844837189, -0.008106614463031292, -0.03620006516575813, -0.04294778034090996, -0.03233944624662399, -0.012489157728850842, 0.007459220942109823, 0.020353717729449272, 0.0229808259755373, 0.01641136221587658, 0.004837858956307173, -0.006483022123575211, -0.013327684253454208, -0.013884780928492546, -0.00902311410754919, -0.0015189707046374679, 0.0053092194721102715, 0.008953265845775604, 0.008542709052562714, 0.0049120294861495495, 4.505457581951779e-18, -0.00408173818141222, -0.0058965496718883514, -0.005129413213580847, -0.0025216881185770035, 0.0005971611244603992, 0.002930146176367998, 0.0037149868439882994, 0.0029289592057466507, 0.0011659023584797978, -0.0007088258280418813, -0.001948696095496416, -0.002197633497416973, -0.001555857714265585, -0.0004516888002399355, 0.0005925549776293337, 0.0011859850492328405, 0.0011967073660343885, 0.0007494982564821839, 0.00012100829917471856, -0.00040367909241467714, -0.0006465080659836531, -0.0005828231805935502, -0.0003149035619571805, -5.396304011506329e-19, 0.00022685996373184025, 0.000301943946396932, 0.0002399887453066185, 0.00010675669182091951, -2.2614254703512415e-05, -9.788921306608245e-05, -0.00010762633610283956, -7.201178232207894e-05, -2.3654747565160505e-05, 1.1430817721702624e-05, 2.3704214981989935e-05, 1.866214552137535e-05, 8.142941624100786e-06, 1.1566422699615941e-06, -4.19646397631368e-07, 6.418367226590505e-11), (-3.705573348167235e-11, -1.8747122965123708e-07, -3.4076085739798145e-06, -1.0263525837217458e-05, -1.4425813787966035e-05, -5.5889672694320325e-06, 2.145342114090454e-05, 5.766989852418192e-05, 7.87377794040367e-05, 5.656717621604912e-05, -2.0312420019763522e-05, -0.00012931831588502973, -0.00021339493105188012, -0.00020477826183196157, -6.599122571060434e-05, 0.00017297183512710035, 0.000407091632951051, 0.0004937569610774517, 0.0003269618027843535, -8.565827738493681e-05, -0.0005892498884350061, -0.0009255425538867712, -0.000851343444082886, -0.00028369080973789096, 0.00060568394837901, 0.001415554084815085, 0.0016780765727162361, 0.001102820155210793, -0.00021540156740229577, -0.0017509673489257693, -0.002729478059336543, -0.0024908462073653936, -0.0008753273286856711, 0.001574270660057664, 0.0037459260784089565, 0.004428592044860125, 0.0029375965241342783, -0.00040842508315108716, -0.004245287273079157, -0.006666970439255238, -0.0061178081668913364, -0.0022789821960031986, 0.003517644014209509, 0.008656017482280731, 0.010340848006308079, 0.0070084258913993835, -0.0006261211819946766, -0.009489303454756737, -0.015257527120411396, -0.01431234274059534, -0.00571784283965826, 0.007759445812553167, 0.020266883075237274, 0.02512005902826786, 0.017916040495038033, -0.00080090545816347, -0.024621054530143738, -0.042795248329639435, -0.043910231441259384, -0.02044377662241459, 0.027590854093432426, 0.09150044620037079, 0.15596452355384827, 0.20373624563217163, 0.22135168313980103, 0.20373624563217163, 0.15596452355384827, 0.09150044620037079, 0.027590854093432426, -0.02044377475976944, -0.043910231441259384, -0.042795244604349136, -0.024621054530143738, -0.00080090545816347, 0.017916040495038033, 0.02512005902826786, 0.020266881212592125, 0.007759446278214455, -0.005717843305319548, -0.014312343671917915, -0.015257527120411396, -0.009489302523434162, -0.0006261212402023375, 0.007008424494415522, 0.010340850800275803, 0.008656018413603306, 0.003517644014209509, -0.0022789817303419113, -0.006117809098213911, -0.006666971370577812, -0.004245286341756582, -0.000408425199566409, 0.0029375965241342783, 0.004428592044860125, 0.0037459249142557383, 0.0015742711257189512, -0.0008753271540626884, -0.0024908457417041063, -0.0027294792234897614, -0.001750967581756413, -0.0002154015382984653, 0.0011028196895495057, 0.001678076689131558, 0.0014155536191537976, 0.0006056837737560272, -0.00028369095525704324, -0.0008513436187058687, -0.0009255425538867712, -0.0005892502376809716, -8.565828466089442e-05, 0.0003269617154728621, 0.000493756786454469, 0.00040709186578169465, 0.00017297183512710035, -6.599121115868911e-05, -0.00020477840735111386, -0.00021339488739613444, -0.00012931821402162313, -2.0312420019763522e-05, 5.6567219871794805e-05, 7.873763388488442e-05, 5.766980393673293e-05, 2.1453459339682013e-05, -5.588959993474418e-06, -1.4425751942326315e-05, -1.026340942189563e-05, -3.4076085739798145e-06, -1.8747122965123708e-07, -3.705573348167235e-11), (1.2715902845861357e-25, 7.364256475739239e-07, 4.447413175512338e-06, 8.244196578743868e-06, 3.640827571871341e-06, -1.5360677934950218e-05, -4.226356031722389e-05, -5.587835767073557e-05, -3.1821036827750504e-05, 3.6571142118191347e-05, 0.00012209014676045626, 0.00016806281928438693, 0.00011862195970024914, -3.811504939221777e-05, -0.00024164006754290313, -0.00037221016827970743, -0.00031158121419139206, -2.538206899771467e-05, 0.00038278300780802965, 0.0006922027096152306, 0.0006712949252687395, 0.00022526267275679857, -0.0004996582283638418, -0.0011364774545654655, -0.001265216968022287, -0.0006620368221774697, 0.0005066034500487149, 0.0016821094322949648, 0.0021554117556661367, 0.0014632059028372169, -0.00026843929663300514, -0.0022574239410459995, -0.003382078604772687, -0.002776381094008684, -0.00040616956539452076, 0.002725347876548767, 0.004946479573845863, 0.004762150347232819, 0.0017720636678859591, -0.0028667578008025885, -0.006797891575843096, -0.007597233634442091, -0.004169072024524212, 0.0023547124583274126, 0.008828925900161266, 0.011511356569826603, 0.008095262572169304, -0.0006871743826195598, -0.010882032103836536, -0.016920581459999084, -0.014449181966483593, -0.003035283414646983, 0.012767491862177849, 0.024886496365070343, 0.02541721798479557, 0.01099467370659113, -0.014290337450802326, -0.03915943577885628, -0.04899030178785324, -0.03192954510450363, 0.015281262807548046, 0.08446907997131348, 0.15776541829109192, 0.2135550081729889, 0.23437745869159698, 0.2135550081729889, 0.15776541829109192, 0.08446907997131348, 0.015281262807548046, -0.03192954510450363, -0.04899030178785324, -0.03915943205356598, -0.0142903383821249, 0.01099467370659113, 0.02541721798479557, 0.024886496365070343, 0.0127674899995327, -0.003035283414646983, -0.014449182897806168, -0.016920583322644234, -0.010882032103836536, -0.0006871742662042379, 0.008095263503491879, 0.011511354707181454, 0.008828927762806416, 0.0023547126911580563, -0.004169072024524212, -0.007597232237458229, -0.006797893438488245, -0.002866758033633232, 0.0017720634350553155, 0.004762151278555393, 0.004946479573845863, 0.002725347876548767, -0.0004061694198753685, -0.0027763820253312588, -0.003382077906280756, -0.0022574234753847122, -0.00026843941304832697, 0.0014632060192525387, 0.002155411522835493, 0.0016821088502183557, 0.0005066034500487149, -0.0006620365893468261, -0.0012652166187763214, -0.0011364779202267528, -0.0004996583447791636, 0.00022526267275679857, 0.0006712952745147049, 0.0006922028260305524, 0.0003827829204965383, -2.5382058083778247e-05, -0.0003115813888143748, -0.00037221016827970743, -0.00024164002388715744, -3.811507849604823e-05, 0.00011862193787237629, 0.00016806268831714988, 0.00012209014676045626, 3.65711712220218e-05, -3.182097862008959e-05, -5.5878263083286583e-05, -4.226363671477884e-05, -1.5360656107077375e-05, 3.640812110461411e-06, 8.244102900789585e-06, 4.447413175512338e-06, 7.364256475739239e-07, 1.2715902845861357e-25)]</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>90800</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>108000</value></param>
<param><key>min</key><value>87000</value></param>
<param><key>num_steps</key><value>(108000-87000)/100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>((100 + 59) * 2 * 1000) / 2 + 6000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>high</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>6</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>low</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>6</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_interp</value></param>
<param><key>value</key><value>2.2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>min_interp</value></param>
<param><key>value</key><value>1.3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_taps</value></param>
<param><key>value</key><value>[0.0009182306239381433, -0.00025654269848018885, -0.0013555705081671476, -0.001962132751941681, -0.0018382493872195482, -0.0010178526863455772, 0.00020125597075093538, 0.0013654007343575358, 0.002033853903412819, 0.0019456685986369848, 0.001121374312788248, -0.00014003500109538436, -0.0013694431399926543, -0.0021020700223743916, -0.002053168136626482, -0.0012285460252314806, 7.292648660950363e-05, 0.0013675241498276591, 0.002166450023651123, 0.002160380594432354, 0.0013391001848503947, -1.1134821948207737e-18, -0.001359489164315164, -0.00222667190246284, -0.00226693507283926, -0.0014527522725984454, -7.865211955504492e-05, 0.0013452036073431373, 0.0022824229672551155, 0.002372455084696412, 0.0015692014712840319, 0.0001629147882340476, -0.0013245539739727974, -0.002333402168005705, -0.0024765627458691597, -0.0016881315968930721, -0.0002526503521949053, 0.0012974482960999012, 0.0023793214932084084, 0.0025788790080696344, 0.0018092120299115777, 0.00034769895137287676, -0.001263816375285387, -0.0024199059698730707, -0.0026790250558406115, -0.001932099461555481, -0.0004478787013795227, 0.0012236111797392368, 0.002454895991832018, 0.0027766244020313025, 0.0020564382430166006, 0.000552986457478255, -0.0011768086114898324, -0.002484048716723919, -0.002871304051950574, -0.0021818627137690783, -0.0006627980037592351, 0.001123407855629921, 0.0025071382988244295, 0.002962695434689522, 0.002307996852323413, 0.0007770691299811006, -0.0010634318459779024, -0.002523957286030054, -0.0030504364985972643, -0.0024344578851014376, -0.0008955357479862869, 0.000996927497908473, 0.0025343175511807203, 0.003134173573926091, 0.002560855122283101, 0.001017915434204042, -0.0009239654755219817, -0.002538051689043641, -0.003213561372831464, -0.002686793217435479, -0.0011439077788963914, 0.0008446403662674129, 0.0025350130163133144, 0.003288266249001026, 0.0028118735644966364, 0.0012731956085190177, -0.0007590703899040818, -0.0025250769685953856, -0.0033579657319933176, -0.0029356940649449825, -0.0014054457424208522, 0.0006673974567092955, 0.002508141566067934, 0.003422351088374853, 0.0030578530859202147, 0.0015403105644509196, -0.0005697865271940827, -0.0024841276463121176, -0.003481128253042698, -0.0031779485289007425, -0.0016774289542809129, 0.0004664254083763808, 0.002452980726957321, 0.003534019226208329, 0.0032955820206552744, 0.0018164274515584111, -0.00035752408439293504, -0.002414669143036008, -0.0035807627718895674, -0.0034103572834283113, -0.00195692153647542, 0.0002433142944937572, 0.002369186608120799, 0.003621115582063794, 0.003521884558722377, 0.0020985177252441645, -0.00012404864537529647, -0.002316551050171256, -0.0036548543721437454, -0.0036297801416367292, -0.0022408131044358015, 6.611300189243871e-18, 0.0022568050771951675, 0.0036817756481468678, 0.003733669174835086, 0.0023833992891013622, 0.00012853949738200754, -0.0021900166757404804, -0.00370169710367918, -0.003833186812698841, -0.0025258618406951427, -0.000261259323451668, 0.002116277813911438, 0.003714458318427205, 0.003927977290004492, 0.002667783061042428, 0.00039783157990314066, -0.0020357053726911545, -0.0037199221551418304, -0.00401770044118166, -0.0028087422251701355, -0.0005379121284931898, 0.001948440563865006, 0.003717973828315735, 0.004102027975022793, 0.0029483186081051826, 0.0006811417988501489, -0.001854648464359343, -0.003708523465320468, -0.004180646501481533, -0.0030860919505357742, -0.0008271473925560713, 0.0017545174341648817, 0.0036915054079145193, 0.004253261256963015, 0.0032216450199484825, 0.000975543400272727, -0.001648259349167347, -0.003666879143565893, -0.0043195937760174274, -0.0033545633777976036, -0.0011259327875450253, 0.0015361076220870018, 0.0036346286069601774, 0.004379383288323879, 0.0034844393376260996, 0.0012779090320691466, -0.0014183175517246127, -0.0035947635769844055, -0.004432390909641981, -0.0036108712665736675, -0.001431056996807456, 0.0012951655080541968, 0.0035473189782351255, 0.004478397313505411, 0.0037334668450057507, 0.0015849546762183309, -0.001166946836747229, -0.003492355812340975, -0.004517205059528351, -0.0038518430665135384, -0.0017391747096553445, 0.0010339765576645732, 0.0034299599938094616, 0.004548639990389347, 0.003965628333389759, 0.0018932860111817718, -0.0008965870947577059, -0.003360242350026965, -0.004572550766170025, -0.004074465483427048, -0.0020468549337238073, 0.0007551274029538035, 0.003283339086920023, 0.004588809795677662, 0.004178009927272797, 0.0021994474809616804, -0.0006099619786255062, -0.0031994106248021126, -0.004597314167767763, -0.004275932442396879, -0.0023506300058215857, 0.0004614694626070559, 0.003108641365543008, 0.004597986117005348, 0.0043679228983819485, 0.002499972004443407, -0.00031004135962575674, -0.003011238994076848, -0.004590773489326239, -0.004453686065971851, -0.0026470464654266834, 0.00015608056855853647, 0.002907434245571494, 0.004575648810714483, 0.004532947670668364, 0.0027914319653064013, -5.5674106639111386e-18, -0.0027974797412753105, -0.0045526111498475075, -0.004605453927069902, -0.002932714531198144, -0.00015777887892909348, 0.0026816485915333033, 0.004521685652434826, 0.004670972004532814, 0.0030704885721206665, 0.00031682755798101425, -0.002560234861448407, -0.004482922609895468, -0.004729289561510086, -0.0032043587416410446, -0.0004767120990436524, 0.002433551475405693, 0.0044363983906805515, 0.0047802189365029335, 0.0033339415676891804, 0.0006369944312609732, -0.0023019290529191494, -0.004382215905934572, -0.004823595751076937, -0.003458866151049733, -0.0007972343591973186, 0.0021657152101397514, 0.004320500884205103, 0.004859279375523329, 0.0035787762608379126, 0.0009569909307174385, -0.00202527386136353, -0.004251406062394381, -0.004887153394520283, -0.003693331265822053, -0.0011158237466588616, 0.0018809823086485267, 0.0041751074604690075, 0.004907128866761923, 0.003802207065746188, 0.001273295027203858, -0.001733231358230114, -0.004091804381459951, -0.004919140134006739, -0.0039050988852977753, -0.001428971067070961, 0.0015824235742911696, 0.00400172034278512, 0.004923148546367884, 0.00400172034278512, 0.0015824235742911696, -0.001428971067070961, -0.0039050988852977753, -0.004919140134006739, -0.004091804381459951, -0.001733231358230114, 0.001273295027203858, 0.003802207065746188, 0.004907128866761923, 0.0041751074604690075, 0.0018809823086485267, -0.0011158237466588616, -0.003693331265822053, -0.004887153394520283, -0.004251406062394381, -0.00202527386136353, 0.0009569909307174385, 0.0035787762608379126, 0.004859279375523329, 0.004320500884205103, 0.0021657152101397514, -0.0007972343591973186, -0.003458866151049733, -0.004823595751076937, -0.004382215905934572, -0.0023019290529191494, 0.0006369944312609732, 0.0033339415676891804, 0.0047802189365029335, 0.0044363983906805515, 0.002433551475405693, -0.0004767120990436524, -0.0032043587416410446, -0.004729289561510086, -0.004482922609895468, -0.002560234861448407, 0.00031682755798101425, 0.0030704885721206665, 0.004670972004532814, 0.004521685652434826, 0.0026816485915333033, -0.00015777887892909348, -0.002932714531198144, -0.004605453927069902, -0.0045526111498475075, -0.0027974797412753105, -5.5674106639111386e-18, 0.0027914319653064013, 0.004532947670668364, 0.004575648810714483, 0.002907434245571494, 0.00015608056855853647, -0.0026470464654266834, -0.004453686065971851, -0.004590773489326239, -0.003011238994076848, -0.00031004135962575674, 0.002499972004443407, 0.0043679228983819485, 0.004597986117005348, 0.003108641365543008, 0.0004614694626070559, -0.0023506300058215857, -0.004275932442396879, -0.004597314167767763, -0.0031994106248021126, -0.0006099619786255062, 0.0021994474809616804, 0.004178009927272797, 0.004588809795677662, 0.003283339086920023, 0.0007551274029538035, -0.0020468549337238073, -0.004074465483427048, -0.004572550766170025, -0.003360242350026965, -0.0008965870947577059, 0.0018932860111817718, 0.003965628333389759, 0.004548639990389347, 0.0034299599938094616, 0.0010339765576645732, -0.0017391747096553445, -0.0038518430665135384, -0.004517205059528351, -0.003492355812340975, -0.001166946836747229, 0.0015849546762183309, 0.0037334668450057507, 0.004478397313505411, 0.0035473189782351255, 0.0012951655080541968, -0.001431056996807456, -0.0036108712665736675, -0.004432390909641981, -0.0035947635769844055, -0.0014183175517246127, 0.0012779090320691466, 0.0034844393376260996, 0.004379383288323879, 0.0036346286069601774, 0.0015361076220870018, -0.0011259327875450253, -0.0033545633777976036, -0.0043195937760174274, -0.003666879143565893, -0.001648259349167347, 0.000975543400272727, 0.0032216450199484825, 0.004253261256963015, 0.0036915054079145193, 0.0017545174341648817, -0.0008271473925560713, -0.0030860919505357742, -0.004180646501481533, -0.003708523465320468, -0.001854648464359343, 0.0006811417988501489, 0.0029483186081051826, 0.004102027975022793, 0.003717973828315735, 0.001948440563865006, -0.0005379121284931898, -0.0028087422251701355, -0.00401770044118166, -0.0037199221551418304, -0.0020357053726911545, 0.00039783157990314066, 0.002667783061042428, 0.003927977290004492, 0.003714458318427205, 0.002116277813911438, -0.000261259323451668, -0.0025258618406951427, -0.003833186812698841, -0.00370169710367918, -0.0021900166757404804, 0.00012853949738200754, 0.0023833992891013622, 0.003733669174835086, 0.0036817756481468678, 0.0022568050771951675, 6.611300189243871e-18, -0.0022408131044358015, -0.0036297801416367292, -0.0036548543721437454, -0.002316551050171256, -0.00012404864537529647, 0.0020985177252441645, 0.003521884558722377, 0.003621115582063794, 0.002369186608120799, 0.0002433142944937572, -0.00195692153647542, -0.0034103572834283113, -0.0035807627718895674, -0.002414669143036008, -0.00035752408439293504, 0.0018164274515584111, 0.0032955820206552744, 0.003534019226208329, 0.002452980726957321, 0.0004664254083763808, -0.0016774289542809129, -0.0031779485289007425, -0.003481128253042698, -0.0024841276463121176, -0.0005697865271940827, 0.0015403105644509196, 0.0030578530859202147, 0.003422351088374853, 0.002508141566067934, 0.0006673974567092955, -0.0014054457424208522, -0.0029356940649449825, -0.0033579657319933176, -0.0025250769685953856, -0.0007590703899040818, 0.0012731956085190177, 0.0028118735644966364, 0.003288266249001026, 0.0025350130163133144, 0.0008446403662674129, -0.0011439077788963914, -0.002686793217435479, -0.003213561372831464, -0.002538051689043641, -0.0009239654755219817, 0.001017915434204042, 0.002560855122283101, 0.003134173573926091, 0.0025343175511807203, 0.000996927497908473, -0.0008955357479862869, -0.0024344578851014376, -0.0030504364985972643, -0.002523957286030054, -0.0010634318459779024, 0.0007770691299811006, 0.002307996852323413, 0.002962695434689522, 0.0025071382988244295, 0.001123407855629921, -0.0006627980037592351, -0.0021818627137690783, -0.002871304051950574, -0.002484048716723919, -0.0011768086114898324, 0.000552986457478255, 0.0020564382430166006, 0.0027766244020313025, 0.002454895991832018, 0.0012236111797392368, -0.0004478787013795227, -0.001932099461555481, -0.0026790250558406115, -0.0024199059698730707, -0.001263816375285387, 0.00034769895137287676, 0.0018092120299115777, 0.0025788790080696344, 0.0023793214932084084, 0.0012974482960999012, -0.0002526503521949053, -0.0016881315968930721, -0.0024765627458691597, -0.002333402168005705, -0.0013245539739727974, 0.0001629147882340476, 0.0015692014712840319, 0.002372455084696412, 0.0022824229672551155, 0.0013452036073431373, -7.865211955504492e-05, -0.0014527522725984454, -0.00226693507283926, -0.00222667190246284, -0.001359489164315164, -1.1134821948207737e-18, 0.0013391001848503947, 0.002160380594432354, 0.002166450023651123, 0.0013675241498276591, 7.292648660950363e-05, -0.0012285460252314806, -0.002053168136626482, -0.0021020700223743916, -0.0013694431399926543, -0.00014003500109538436, 0.001121374312788248, 0.0019456685986369848, 0.002033853903412819, 0.0013654007343575358, 0.00020125597075093538, -0.0010178526863455772, -0.0018382493872195482, -0.001962132751941681, -0.0013555705081671476, -0.00025654269848018885, 0.0009182306239381433]</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pilot_var</value></param>
<param><key>block_id</key><value>pilot_prob</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>15</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>red</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rssi_ref</value></param>
<param><key>value</key><value>91.5</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>rssi_var</value></param>
<param><key>block_id</key><value>rssi_prob</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_audio</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_sdr</value></param>
<param><key>value</key><value>768000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>subbands</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>tau</key><value>deemphasis</value></param>
</block>
<block>
<key>analog_fm_deemph</key>
<param><key>id</key><value>analog_fm_deemph_0_0</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>tau</key><value>deemphasis</value></param>
</block>
<block>
<key>analog_pll_refout_cc</key>
<param><key>id</key><value>analog_pll_refout_cc_0</value></param>
<param><key>w</key><value>2 * math.pi * 4 / samp_rate</value></param>
<param><key>max_freq</key><value>2 * math.pi * (19005) / samp_rate</value></param>
<param><key>min_freq</key><value>2 * math.pi * (18995) / samp_rate</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>samp_rate / (2 * math.pi * (samp_rate * 0.5))</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>axax</value></param>
<param><key>avg_alpha</key><value>0.66</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0,1</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>-10</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>MPX</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_2</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_3</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_4</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>vlen</key><value>subbands</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_1</value></param>
<param><key>vlen</key><value>subbands</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0_0</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>subbands*2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>mpx_delay</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1</value></param>
<param><key>comment</key><value>FUCK THIS SHIT</value></param>
<param><key>delay</key><value>51</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_2</value></param>
<param><key>delay</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>subbands</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>subbands</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/konrad/zip.raw</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/konrad/917m2o.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1</value></param>
<param><key>vlen</key><value>subbands</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>samp_rate/bw_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>2</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>samp_rate/15</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1/float(samp_rate/15)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_1</value></param>
<param><key>vlen</key><value>subbands</value></param>
<param><key>length</key><value>avg</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1/float(avg)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_1_0</value></param>
<param><key>vlen</key><value>subbands</value></param>
<param><key>length</key><value>avg</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1/float(avg)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_1_1</value></param>
<param><key>length</key><value>samp_rate/bw_rate</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1/float(samp_rate/bw_rate)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_2</value></param>
<param><key>length</key><value>samp_rate/15</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1/float(samp_rate/15)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>0.5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>samp_rate / float(1000)  / 2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>samp_rate / float(1000)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>1/float(subbands)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_4</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>subbands</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_x_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>True</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>subbands</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>subbands</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate_sdr</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_transcendental</key>
<param><key>id</key><value>blocks_transcendental_0</value></param>
<param><key>name</key><value>sqrt</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>subbands</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_psk_demod</key>
<param><key>id</key><value>digital_psk_demod_0</value></param>
<param><key>differential</key><value>False</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>freq_bw</key><value>6.28/100.0</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>constellation_points</key><value>2</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>samples_per_symbol</key><value>4</value></param>
<param><key>timing_bw</key><value>6.28/100.0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>bandwidth</key><value>5</value></param>
<param><key>boost</key><value>boost</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, bandwidth = 5, low = 3,  high = 5, boost = 1.0, reduce = 1.0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Embedded Python Block',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.bandwidth = bandwidth

        self.low = low
        self.high = high

        self.boost = boost
        self.reduce = reduce
        
        
    def work(self, input_items, output_items):
        #for i in range(0, len(output_items[0])):
        for i in range(0, 1):
            if(input_items[0][i] &gt; self.high):
                self.bandwidth = max(self.bandwidth - self.reduce, 0)
                output_items[0][i]=self.bandwidth
            elif(input_items[0][i] &lt; self.low):
                self.bandwidth = min(self.bandwidth + self.boost, 13)
                output_items[0][i]=self.bandwidth

        #return(len(output_items[0]))
        return(1)
</value></param>
<param><key>high</key><value>high</value></param>
<param><key>low</key><value>low</value></param>
<param><key>reduce</key><value>red</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_interp</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, from_min=-10.0, from_max=10.0, to_min=0.0, to_max=1.0, div=1):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Interp',   # will show up in GRC
            in_sig=[(np.float32,1024)],
            out_sig=[(np.float32,1024)]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.from_min = from_min
        self.from_max = from_max
        self.to_min = to_min
        self.to_max = to_max
        self.div = div

    def work(self, input_items, output_items):
        a = input_items[0][:].reshape(-1, self.div).mean(1).repeat(self.div).reshape(-1, 1024)

        output_items[0][:] = np.interp(a, [self.from_min, self.from_max], [self.to_min, self.to_max])
        return len(output_items[0])
</value></param>
<param><key>div</key><value>div</value></param>
<param><key>from_max</key><value>max_interp</value></param>
<param><key>from_min</key><value>min_interp</value></param>
<param><key>to_max</key><value>1.0</value></param>
<param><key>to_min</key><value>0.0</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1</value></param>
<param><key>fft_size</key><value>subbands</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(subbands)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_1_0</value></param>
<param><key>fft_size</key><value>subbands</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(subbands)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_2</value></param>
<param><key>fft_size</key><value>subbands</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value>window.rectangular(subbands)</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>taps</key><value>firs[int(bw)]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>pilot_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_1</value></param>
<param><key>center_freq</key><value>freq_offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_sdr</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_1_0_0</value></param>
<param><key>center_freq</key><value>57e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(2500.0,250000,2.6e3,2e3,firdes.WIN_HAMMING)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>gr_rds_decoder</key>
<param><key>id</key><value>gr_rds_decoder_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>high_pass_filter</key>
<param><key>id</key><value>high_pass_filter_0_0</value></param>
<param><key>cutoff_freq</key><value>30</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>width</key><value>25</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>high_pass_filter</key>
<param><key>id</key><value>high_pass_filter_0_0_0</value></param>
<param><key>cutoff_freq</key><value>30</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>width</key><value>25</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>high_pass_filter</key>
<param><key>id</key><value>high_pass_filter_0_0_1</value></param>
<param><key>cutoff_freq</key><value>70e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>10e3</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_2</value></param>
<param><key>cutoff_freq</key><value>15e3</value></param>
<param><key>decim</key><value>samp_rate / samp_rate_audio</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1_2_0</value></param>
<param><key>cutoff_freq</key><value>15e3</value></param>
<param><key>decim</key><value>samp_rate / samp_rate_audio</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_BLACKMAN</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>notebook_0</value></param>
<param><key>labels</key><value>['Baseband', 'MPX', 'Pilot', 'L+R', 'L-R', 'L-R\'', 'Noise','L','R']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq*1000-freq_offset</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value>airspyhf=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_sdr</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>19000/float(samp_rate)</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>pilot_prob</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>100</value></param>
<param><key>samp_rate</key><value>19000</value></param>
<param><key>sym_rate</key><value>2375</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>rssi_prob</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>Baseband</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>MPX</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>L-R</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0</value></param>
<param><key>stream_id</key><value>L</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>R</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_1</value></param>
<param><key>stream_id</key><value>L+R</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_2</value></param>
<param><key>stream_id</key><value>N</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_2_0_0</value></param>
<param><key>stream_id</key><value>L-R_mags</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_2_0_0_0</value></param>
<param><key>stream_id</key><value>N_mags</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_2_0_0_1</value></param>
<param><key>stream_id</key><value>L-R_bins</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_2_0_0_1_0</value></param>
<param><key>stream_id</key><value>Blend</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>stream_id</key><value>Pilot</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_2</value></param>
<param><key>stream_id</key><value>RSSI</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_0</value></param>
<param><key>stream_id</key><value>USN</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_1</value></param>
<param><key>stream_id</key><value>Dev_Pilot</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2_0</value></param>
<param><key>stream_id</key><value>L-R'</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_4</value></param>
<param><key>stream_id</key><value>RDS</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>Baseband</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>MPX</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0</value></param>
<param><key>stream_id</key><value>Pilot</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_0_0</value></param>
<param><key>stream_id</key><value>L-R'</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_0_0_0</value></param>
<param><key>stream_id</key><value>L-R'</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_0_0_0_0</value></param>
<param><key>stream_id</key><value>R</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_0_1</value></param>
<param><key>stream_id</key><value>L+R</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_0_1_0</value></param>
<param><key>stream_id</key><value>L</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_1_2</value></param>
<param><key>stream_id</key><value>L-R</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_1_2_0</value></param>
<param><key>stream_id</key><value>N</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_1_2_0_0</value></param>
<param><key>stream_id</key><value>N_mags</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_1_2_0_0_0</value></param>
<param><key>stream_id</key><value>Blend</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_1_2_1_0</value></param>
<param><key>stream_id</key><value>L-R_bins</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1_1_2_1_1</value></param>
<param><key>stream_id</key><value>L-R_mags</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0</value></param>
<param><key>stream_id</key><value>MPX</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_1_0</value></param>
<param><key>stream_id</key><value>USN</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_2</value></param>
<param><key>stream_id</key><value>L+R</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_2_0</value></param>
<param><key>stream_id</key><value>L-R</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_2_0_0</value></param>
<param><key>stream_id</key><value>N</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_2_0_1</value></param>
<param><key>stream_id</key><value>L-R'</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>MPX</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_11</value></param>
<param><key>stream_id</key><value>MPX</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_12</value></param>
<param><key>stream_id</key><value>RDS</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>decimal_places</key><value>0</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>max_value</key><value>13</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>number_rate</key><value>30</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>bw_rate</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>FIR</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>#</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>80</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0,3</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-10</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>title</key><value>L+R</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_0_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>80</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0,4</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-10</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>title</key><value>L-R</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_0_0_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>80</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0,6</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-10</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>title</key><value>Noise</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_0_0_1</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>80</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0,5</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-10</value></param>
<param><key>samp_rate</key><value>samp_rate_audio</value></param>
<param><key>title</key><value>L-R'</value></param>
<param><key>type</key><value>float</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>analog_fm_deemph_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_deemph_0_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_pll_refout_cc_0</source_block_id><sink_block_id>blocks_delay_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0_0</source_block_id><sink_block_id>blocks_moving_average_xx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1</source_block_id><sink_block_id>virtual_sink_0_0_0_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_2</source_block_id><sink_block_id>axax</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_4</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>virtual_sink_0_0_0_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_1</source_block_id><sink_block_id>virtual_sink_0_0_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>low_pass_filter_1_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_2</source_block_id><sink_block_id>blocks_multiply_xx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_1</source_block_id><sink_block_id>epy_block_interp</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1</source_block_id><sink_block_id>virtual_sink_0_0_0_2_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_transcendental_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_1</source_block_id><sink_block_id>blocks_divide_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_1_0</source_block_id><sink_block_id>blocks_divide_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_1_1</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_2</source_block_id><sink_block_id>pilot_prob</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_2</source_block_id><sink_block_id>virtual_sink_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_abs_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>blocks_multiply_xx_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>blocks_multiply_xx_1_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>virtual_sink_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1</source_block_id><sink_block_id>low_pass_filter_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1_0</source_block_id><sink_block_id>blocks_multiply_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1_1</source_block_id><sink_block_id>blocks_moving_average_xx_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_4</source_block_id><sink_block_id>fft_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>rssi_prob</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>virtual_sink_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>fft_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_transcendental_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>gr_rds_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_demod_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>blocks_probe_signal_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>virtual_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>epy_block_interp</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>epy_block_interp</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>blocks_complex_to_mag_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1</source_block_id><sink_block_id>virtual_sink_0_0_0_2_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_1_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_2</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_pll_refout_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_complex_to_float_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_1</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_1_0_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_rds_decoder_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>high_pass_filter_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>high_pass_filter_0_0_0</source_block_id><sink_block_id>blocks_complex_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>high_pass_filter_0_0_1</source_block_id><sink_block_id>blocks_complex_to_float_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_2</source_block_id><sink_block_id>high_pass_filter_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1_2_0</source_block_id><sink_block_id>high_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>virtual_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0_0_0_0</source_block_id><sink_block_id>analog_fm_deemph_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0_1</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_0_1_0</source_block_id><sink_block_id>analog_fm_deemph_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_1_2</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_1_2_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_1_2_0_0</source_block_id><sink_block_id>blocks_moving_average_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_1_2_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_4</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_1_2_1_0</source_block_id><sink_block_id>blocks_delay_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1_1_2_1_1</source_block_id><sink_block_id>blocks_moving_average_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0</source_block_id><sink_block_id>blocks_complex_to_float_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_1_0</source_block_id><sink_block_id>wxgui_numbersink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_2</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_2_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_2_0_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_2_0_1</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>high_pass_filter_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_11</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_12</source_block_id><sink_block_id>digital_psk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
